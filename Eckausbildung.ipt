# Autodesk Inventor part: Eckausbildung
## iProperties
Created: 2007-06
Part Number: Eckausbildung
Document SubType Name: Sheet Metal
Designer: rj
Author: rj
## Feature names
1. Grobblech1
